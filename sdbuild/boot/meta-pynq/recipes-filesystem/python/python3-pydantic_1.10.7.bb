SUMMARY = "Data validation and settings management using python type hints"
    
HOMEPAGE = "https://github.com/pydantic/pydantic"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=2c02ea30650b91528657db64baea1757"

SRC_URI[sha256sum] = "cfc83c0678b6ba51b0532bea66860617c4cd4251ecf76e9846fa5a9f3454e97e"


PYPI_PACKAGE = "pydantic"   

inherit pypi setuptools3
