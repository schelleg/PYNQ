SUMMARY = "Extensible, Modular, Metadata layer for PYNQ project"
    
HOMEPAGE = "http://github.com/Xilinx/PYNQ-Metadata"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=4d2124d4ae21e284f8fab7ae4d5dd882"

SRC_URI[sha256sum] = "8e0ebb213b4251d095ac92f06fae16715746c36486ec2d28aa515f7594fd649a"

PYPI_PACKAGE = "pynqmetadata"   

inherit pypi setuptools3